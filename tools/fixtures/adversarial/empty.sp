* Empty circuit — no elements
.END
